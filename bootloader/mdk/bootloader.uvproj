# Keil uVision project bootloader.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC8H8K64U Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0x1FFF) IROM(0-0xFFF8) CLOCK(35000000) MODP2
  output: bootloader +hex
  c flags: Optimize=9 SizeSpeed=1
  c include: ..\..\libhb
  link misc: REMOVEUNUSED
  group Source Group 1
    ../src/: main.c isr.asm protocol.c
    ../../libhb/libstc/: stc8h.c
